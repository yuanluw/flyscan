# Keil uVision project Pro.uvproj, settings and files
target FLY MODE (ARM-ADS)
  device: LM4F232H5QC Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Pro
  c flags: Optim=1
  c define: TARGET_IS_TM4C123_RB1
  c include: .\App;..\Project;.\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/: main.c tm4c_int.c
    ./: Startup.s
  group Lib
    ./driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group App
    ./App/: selfUART.c mygpio.c selfPWM.c SYSCLOCk.c PPM_Rec.c PID_Count.c MPU6050.c Angle_Core.c Ultrasonic_Height.c MyADC.c fly_math.c initialize.c gpioInit.c
